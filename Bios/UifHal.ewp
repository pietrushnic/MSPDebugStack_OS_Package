# IAR project UifHal.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F1612 MSP430F1612
  General.GStackSize2: 0
  General.GHeapSize2: 768
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: uController_uif; HAL_STREAM; __ICC430__; MSP430_UIF
  ICC430.newCCIncludePaths: include; src\hil; src\hil\uifv1; src\fw; src\fw\uifv1; src\hal
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  A430.ADefines: U2
  postbuild: "tools\convertEzFetTxt.bat" "$PROJ_DIR$" UifHal
  XLINK.XclFile: config\hal_lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 1024
  General.GHeapSize2: 1024
  ICC430.CCDefines: NDEBUG; uController; HAL_STREAM
  ICC430.newCCIncludePaths: include; src\hil; src\hil\uifv1; src\fw; src\hal
  ICC430.CCOptStrategy: 0
  postbuild: tools\uifhalPostBuild.bat $PROJ_DIR$
  group Config
    config/: hal_lnk430F1612.xcl
  group Hal
    src/fw/uifv1/: cstartup.s43 hal.c HalGlobalVars.c halMain.c
  group Hal/MSP430
    src/hal/macros/: BitSequence.c BlowFuse.c Configure.c EemDataExchange.c EemDataExchangeAFE2xx.c ExecuteFunclet.c ExecuteFuncletJtag.c GetDcoFrequency.c GetInterfaceMode.c GetJtagId.c GetNumOfDevices.c HilCommand.c IsJtagFuseBlown.c MagicPattern.c PollJStateReg430I.c Psa.c ReadAllCpuRegs.c ReadMemBytes.c ReadMemQuick.c ReadMemWords.c Reset430I.c RestoreContext_ReleaseJtag.c SetChainConfiguration.c SetDeviceChainInfo.c SingleStep.c StartJtag.c StartJtagActivationCode.c StopJtag.c SyncJtag_AssertPor_SaveContext.c SyncJtag_Conditional_SaveContext.c UnlockC092.c WaitForEem.c WaitForStorage.c WriteAllCpuRegs.c WriteMemBytes.c WriteMemWords.c
  group Hal/MSP430X
    src/hal/macros/: EemDataExchangeX.c ExecuteFuncletX.c PsaX.c ReadAllCpuRegsX.c ReadMemBytesX.c ReadMemQuickX.c ReadMemWordsX.c RestoreContext_ReleaseJtagX.c SingleStepX.c SyncJtag_AssertPor_SaveContextX.c SyncJtag_Conditional_SaveContextX.c WaitForStorageX.c WriteAllCpuRegsX.c WriteMemBytesX.c WriteMemWordsX.c
  group Hal/MSP430Xv2
    src/hal/macros/: BlowFuseFram.c BlowFuseXv2.c EemDataExchangeXv2.c ExecuteFuncletXv2.c PollJStateReg.c PollJStateRegFR57xx.c PsaXv2.c ReadAllCpuRegsXv2.c ReadMemBytesXv2.c ReadMemQuickXv2.c ReadMemWordsXv2.c ResetXv2.c RestoreContext_ReleaseJtagXv2.c SendJtagMailboxXv2.c SingleStepJState.c SingleStepXv2.c SyncJtag_AssertPor_SaveContextXv2.c SyncJtag_Conditional_SaveContextXv2.c UnlockDeviceXv2.c WriteAllCpuRegsXv2.c WriteFramQuickXv2.c WriteMemBytesXv2.c WriteMemWordsXv2.c
  group Hil
    src/hil/uifv1/: arch.h hil.c hil_2w.c hil_4w.c hil_jsbw.c hilDelays.s43
