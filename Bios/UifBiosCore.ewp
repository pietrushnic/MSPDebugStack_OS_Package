# IAR project UifBiosCore.ewp, settings and files
configuration Debug COM-IRQ (MSP430, debug)
  General.OGChipSelectMenu: MSP430F1612 MSP430F1612
  General.GStackSize2: 512
  General.GHeapSize2: 1224
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: uController_uif; MSP430_UIF
  ICC430.IExtraOptions: --require_prototypes
  ICC430.newCCIncludePaths: include
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  postbuild: "tools\convertEzFetTxt.bat" "$PROJ_DIR$" UifBiosCore
  XLINK.XclFile: config\Bios_lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release COM-IRQ (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG; uController_uif
  ICC430.CCOptLevel: 3
  postbuild: tools\uifbioscorePostBuild.bat $PROJ_DIR$
  group Bios
    src/fw/uifv1/: bios.c bios.h main.c stream.c v3_0p.c v3_0p_hw_uif.c
  group Bios/Config
    config/: Bios_lnk430F1612.xcl
