# IAR project FetComChannel.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EZ_FET
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetComChannel
  XLINK.XclFile: config\ComChannel_Ink430F5528.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/uart/: cstartup_uart.s43
  group ComChannel
    src/uart/: FetUart.c FetUart.h
  group config
    config/: ComChannel_Ink430F5528.xcl
