# IAR project NgUifBios.ewp, settings and files
configuration eZ_FET_DCDC (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: uController_nguif; EZ_FET
  ICC430.newCCIncludePaths: include; src\fw; src\fw\ez_fet; src\fw\ez_fet\USB_config; src\fw\ez_fet\F5xx_F6xx_Core_Lib
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetCore
  XLINK.XclFile: config\Bios_lnk430F5528.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    src/fw/ez_fet/: main.c
  group Bios
    src/fw/ez_fet/: bios.c stream.c v3_0p.c v3_0p_hw_nguif.c
  group Config
    config/: Bios_lnk430F5528.xcl
  group USB
    src/fw/ez_fet/: usbConstructs.c usbConstructs.h usbEventHandling.c usbMain.c
  group USB/F5xx_F6xx_Core_Lib
    src/fw/ez_fet/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group USB/USB_API/USB_CDC_API
    src/fw/ez_fet/USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB/USB_Common
    src/fw/ez_fet/USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB/USB_config
    src/fw/ez_fet/USB_config/: descriptors.c descriptors.h UsbIsr.c
