# IAR project FetDCDC.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: EZ_FET
  ICC430.newCCIncludePaths: include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ eZ_FetDcdc
  XLINK.XclFile: config\Dcdc_lnk430F5528.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    src/dcdc/: cstartup_dcdc.s43
  group config
    config/: Dcdc_lnk430F5528.xcl
  group DCDC
    src/dcdc/: FetDcdc.c
