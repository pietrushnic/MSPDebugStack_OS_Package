# IAR project BSL.ewp, settings and files
configuration RAM_BASED_BSL_FLASH_MODE_eZ_FET (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 400
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: FLASH_WRITE_BSL; eZ_FET
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: tools\convertBsl.bat $PROJ_DIR$ RAM_BSL_FLASH_MODE_eZ_FET
  XLINK.XclFile: CONFIG\lnk430F5509_RAM_AREA.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: BSL430_API.c BSL430_Command_Interpreter.c BSL430_Low_Level_Init.s43 BSL430_USB_PI.c cstartup.s43
  group USB-Headers
    ./: defUSB.h descriptor.h descriptors.h device.h hal_UCS.h Proj_Settings.h types.h usb.h usbapi.h UsbHidReq.h UsbIsr.h
  group USB-Source
    ./: descriptors.c hal_UCS.c usb.c UsbApi.c UsbHidReq.c UsbIsr.c
